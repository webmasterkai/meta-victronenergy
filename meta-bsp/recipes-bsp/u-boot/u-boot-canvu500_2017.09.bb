require u-boot-canvu500.inc
